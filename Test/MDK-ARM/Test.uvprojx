# Keil uVision project Test.uvprojx, settings and files
target Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX
  c include: ..\Startup;..\USER;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group User
    ../USER/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_exti.c
  group MDK-ARM
    ../Startup/: startup_stm32f0xx.s
